# Keil uVision project demo.uvproj, settings and files
target VINP1_AMPIRE_800X480 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: __LCM_800x480__ __1ST_PORT__
  c include: ..\..\..\Lib;..\..\..\..\SYSLIB\Lib;..\..\..\..\GPIO\lib;..\..\..\..\VPOST\Lib;..\..\..\..\NVTFAT\lib;..\..\..\..\SIC\Lib;..\..\..\..\GNAND\Lib;..\..\..\..\I2C\lib;..\..\..\..\GPIO\lib;..\..\I2CS
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32916\N32916.sct
  link misc: --entry 0
  group Source Group 1
    ../../: demo.c LcmCtl.c Smpl_LG303B.c Smpl_NT99050.c Smpl_NT99141.c Smpl_OV7670.c Smpl_OV9660.c Smpl_OV7725.c Smpl_OV9665.c Smpl_GC0308.c Smpl_VPOST.c standalone.c VIN_PacketZooming.c wb_init.s
    ../../../../SYSLIB/Lib/: W55FA95_syslib.lib
    ../../../Lib/: W55FA95_VideoIn.lib
    ../../../../VPOST/Lib/: W55FA95_VPOST_AMPIRE_800x480_18B.lib
    ../../../../I2C/lib/: w55fa95_i2c.lib
    ../../../../GPIO/lib/: w55fa95_gpio.lib
    ../../I2CS/: DrvI2C.c
