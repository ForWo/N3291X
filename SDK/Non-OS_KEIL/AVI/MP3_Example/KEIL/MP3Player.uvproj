# Keil uVision project MP3Player.uvproj, settings and files
target Release (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: MP3Player
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\Lib;..\..\..\SYSLIB\Lib;..\..\..\VPOST\Lib;..\..\..\JPEG\LIB;..\..\..\GNAND\Lib;..\..\..\GPIO\lib;..\..\..\SIC\Lib;..\..\..\SPU\Lib;..\..\..\NVTFAT\lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32916\N32916.sct
  link misc: --entry 0
  group Source Group 1
    ../: Demo_MP3.c standalone.c wb_init.s
    ../../Lib/: AviLib_800x480.lib ima_adpcm_codec.lib mp3lib.lib
    ../../../SYSLIB/Lib/: W55FA95_syslib.lib
    ../../../SIC/Lib/: W55FA95_SIC.lib
    ../../../VPOST/Lib/: W55FA95_VPOST.lib
    ../../../NVTFAT/lib/: W55FA95_nvtfat.lib
    ../../../JPEG/LIB/: w55fa95_jpeglib.lib
    ../../../GNAND/Lib/: w55fa95_GNAND.lib
    ../../../SPU/Lib/: w55fa95_spu.lib
