# Keil uVision project fa95_jpegdemo.uvproj, settings and files
target JPEG_Demo (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: fa95_jpegdemo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\LIB;..\..\..\..\SYSLIB\Lib;..\..\..\..\SIC\Lib;..\..\..\..\GNAND\Lib;..\..\..\..\NVTFAT\lib;..\..\..\..\VPOST\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32916\N32916.sct
  link misc: --entry 0
  group Source Group 1
    ../: standalone.c wb_init.s
    ../../: common.c jpegDec.c jpegEnc.c main.c
    ../../../LIB/: w55fa95_jpeglib.lib
    ../../../../NVTFAT/lib/: W55FA95_nvtfat.lib
    ../../../../VPOST/Lib/: W55FA95_VPOST.lib
    ../../../../SYSLIB/Lib/: W55FA95_syslib.lib
    ../../../../SIC/Lib/: W55FA95_SIC.lib
