# Keil uVision project JpegLib.uvproj, settings and files
target DebugRel (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: w55fa95_jpeglib (library)
  AfterMake: DebugRel.bat
  c flags: Optim=2 wLevel=2
  c define: DIRECT_MAPPING
  c include: ..\..\..\LIB;..\..\..\..\SYSLIB\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group Source Group 1
    ../../: jpegcodec.c
target Release (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: w55fa95_jpeglib (library)
  AfterMake: Release.bat
  c flags: Optim=3 wLevel=2
  c include: ..\..\..\LIB;..\..\..\..\SYSLIB\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
