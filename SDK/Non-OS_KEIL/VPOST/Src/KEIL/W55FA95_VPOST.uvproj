# Keil uVision project W55FA95_VPOST.uvproj, settings and files
target W55FA95_VPOST (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: W55FA95_VPOST (library)
  AfterMake: W55FA95_VPOST.bat
  c flags: Optim=1 wLevel=2
  c include: ..\..\Lib;..\..\..\SYSLIB\Lib;..\..\..\I2C\lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group Source Group 1
    ../: W55FA93_VPOST_GOWORLD_GW9563_480x272.c W55FA93_VPOST_SGMICRO_SGM3727_480x272.c W55FA95_VPOST.C W55FA95_VPOST_AMPIRE_800x480.c W55FA95_VPOST_AMPIRE_800x480_18B.c W55FA95_VPOST_AMPIRE_800x600.c W55FA95_VPOST_AMPIRE_800x600_18B.c W55FA95_VPOST_AMPIRE_800x600_24B.c W55FA95_VPOST_Driver.c W55FA95_VPOST_E50V2A1_800x480.c W55FA95_VPOST_GOWORLD_GW8973.c W55FA95_VPOST_GOWORLD_GWMTF9360A.c W55FA95_VPOST_GOWORLD_GWMTF9406A.c W55FA95_VPOST_HANNSTAR_HSD043I9W1.c W55FA95_VPOST_HIMAX_HX7027.c W55FA95_VPOST_HIMAX_HX7033.c W55FA95_VPOST_HIMAX_HX8346.c W55FA95_VPOST_ILITEK_ILI9322.c W55FA95_VPOST_KD070D10_800x480.c W55FA95_VPOST_SPLC780D.c W55FA95_VPOST_TOPPLY_TD025THEA.c W55FA95_VPOST_TVOUT_D1_720x480.c W55FA95_VPOST_TVOUT_QVGA_320x240.c W55FA95_VPOST_TVOUT_VGA_640x480.c W55FA95_VPOST_ILITEK_ILI6150_24B.c W55FA95_VPOST_ILITEK_ILI9341.c
