# Keil uVision project HID.uvproj, settings and files
target Mouse_Pattern (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: HID_Mouse_Pattern
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: HID_MOUSE
  c include: ..\..\..\lib;..\..\..\..\SYSLIB\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32916\N32916.sct
  link misc: --entry Reset_Go
  group Source Group
    ../: main.c standalone.c wb_init.s HID.c
  group Library Group
    ../../../lib/: w55fa95_UDC_Fullspeed.lib
    ../../../../SYSLIB/Lib/: W55FA95_syslib.lib
    ../../../../VPOST/Lib/: W55FA95_VPOST.lib
    ../../../../KPI/lib/: w55fa95_kpi_11x1_lcd.lib
target Mouse_Keypad (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: HID_Mouse_Keypad
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: HID_MOUSE HID_KEYPAD
  c include: ..\..\..\lib;..\..\..\..\SYSLIB\Lib;..\..\..\..\KPI\lib;..\..\..\..\VPOST\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32916\N32916.sct
  link misc: --entry Reset_Go
target Keyboard_Pattern (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: HID_Keyboard_Pattern
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: HID_KEYBOARD
  c include: ..\..\..\lib;..\..\..\..\SYSLIB\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32916\N32916.sct
  link misc: --entry Reset_Go
target Keyboard_Keypad (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: HID_Keyboard_Keypad
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: HID_KEYBOARD HID_KEYPAD
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32916\N32916.sct
  link misc: --entry Reset_Go
