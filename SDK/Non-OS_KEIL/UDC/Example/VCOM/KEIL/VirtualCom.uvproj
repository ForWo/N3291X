# Keil uVision project VirtualCom.uvproj, settings and files
target VirtualCom (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: VirtualCom
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\lib;..\..\..\..\SYSLIB\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32916\N32916.sct
  link misc: --entry Reset_Go
  group Source Group
    ../: main.c standalone.c wb_init.s
  group Library Group
    ../../../../SYSLIB/Lib/: W55FA95_syslib.lib
    ../../../lib/: w55fa95_UDC.lib
    ../: VirtualCom.c
