# Keil uVision project Video_Class_Demo.uvproj, settings and files
target Vin_1stP_Format_Both (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: Video_Class_Demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCM_320x240__ __UVC_VIN__ __1ST_PORT__
  c include: ..\..\..\..\lib;..\..\..\..\..\SYSLIB\Lib;..\..\I2CS;..\..\..\..\..\I2C\lib;..\..\..\..\..\VideoIn\Lib;..\..\..\..\..\JPEG\LIB;..\..\..\..\..\GPIO\lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\N32916\N32916.sct
  link misc: --entry 0
  group Source Group 1
    ../../: demo.c Smpl_I2C.c standalone.c uvc_main.c wb_init.s Smpl_NT99141.c
    ../../../../lib/: w55fa95_UVC.lib w55fa95_UDC.lib w55fa95_UVC_YUV_Only.lib w55fa95_UVC_MJPEG_Only.lib
    ../../../../../I2C/lib/: w55fa95_i2c.lib
    ../../../../../VideoIn/Lib/: W55FA95_VideoIn.lib
    ../../../../../JPEG/LIB/: w55fa95_jpeglib.lib
    ../../../../../SYSLIB/Lib/: W55FA95_syslib.lib
    ../../I2CS/: DrvI2C.c
    ../../../../../GPIO/lib/: w55fa95_gpio.lib
target Vin_1stP_Format_YUV_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: Video_Class_Demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCM_320x240__ __UVC_VIN__ __1ST_PORT__
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\N32916\N32916.sct
  link misc: --entry 0
target Vin_1stP_Format_MJPEG_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: Video_Class_Demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCM_320x240__ __UVC_VIN__ __1ST_PORT__
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\N32916\N32916.sct
  link misc: --entry 0
target Fixed_Format_Both (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: Video_Class_Demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCM_320x240__ __2ND_PORT__
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\N32916\N32916.sct
  link misc: --entry 0
target Fixed_Format_YUV_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: Video_Class_Demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCM_320x240__ __2ND_PORT__
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\N32916\N32916.sct
  link misc: --entry 0
target Fixed_Format_MJPEG_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: Video_Class_Demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCM_320x240__ __2ND_PORT__
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\N32916\N32916.sct
  link misc: --entry 0
