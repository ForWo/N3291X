# Keil uVision project mass_storage_FullSpeed_CDROM.uvproj, settings and files
target NAND0_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: mass_storage_FullSpeed_CDROM
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __NAND__
  c include: ..\..\..\lib;..\..\..\..\SYSLIB\Lib;..\..\..\..\GNAND\Lib;..\..\..\..\NVTFAT\lib;..\..\..\..\SIC\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32916\N32916.sct
  link misc: --entry Reset_Go
  group Source Group 1
    ../: main.c standalone.c wb_init.s
    ../../../lib/: w55fa95_MSC_SD_CDROM.lib w55fa95_MSC_NAND_CDROM.lib w55fa95_MSC_RAM_CDROM.lib w55fa95_MSC_NAND_SD_CDROM.lib w55fa95_UDC_Fullspeed.lib w55fa95_MSC_SPI_CDROM.lib
    ../../../../SYSLIB/Lib/: W55FA95_syslib.lib
    ../../../../GNAND/Lib/: w55fa95_GNAND.lib
    ../../../../NVTFAT/lib/: W55FA95_nvtfat.lib
    ../../../../SIC/Lib/: W55FA95_SIC.lib W55FA95_SIC_KLE_MUL2.lib
    ../../../../SPI/Lib/: w55fa95_SPI.lib
target NAND0&2 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: mass_storage_FullSpeed_CDROM
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __NAND__ __TWO_NAND__
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32916\N32916.sct
  link misc: --entry Reset_Go
target NAND&SD (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: mass_storage_FullSpeed_CDROM
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __NAND__ __SD__
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32916\N32916.sct
  link misc: --entry Reset_Go
target SD0_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: mass_storage_FullSpeed_CDROM
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_ONLY__ __SD__
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32916\N32916.sct
  link misc: --entry Reset_Go
target SD0&1 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: mass_storage_FullSpeed_CDROM
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_ONLY__ __SD__ __TWO_SD__
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32916\N32916.sct
  link misc: --entry Reset_Go
target RamDiskOnly (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: mass_storage_FullSpeed_CDROM
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __RAM_DISK_ONLY__
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32916\N32916.sct
  link misc: --entry Reset_Go
target SPI (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: mass_storage_FullSpeed_CDROM
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SPI_ONLY__
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32916\N32916.sct
  link misc: --entry Reset_Go
