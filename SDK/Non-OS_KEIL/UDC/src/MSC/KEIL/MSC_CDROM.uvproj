# Keil uVision project MSC_CDROM.uvproj, settings and files
target SD (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: w55fa95_MSC_SD_CDROM (library)
  AfterMake: CDROM_SD.bat
  c flags: Optim=1 wLevel=2
  c define: TEST_CDROM TEST_SD
  c include: ..\..\..\lib;..\..\..\..\SYSLIB\Lib;..\..\..\..\NVTFAT\lib;..\..\..\..\GNAND\Lib;..\..\..\..\SIC\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group Source Group 1
    ../../MSC/: mscd.c
target NAND (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: w55fa95_MSC_NAND_CDROM (library)
  AfterMake: CDROM_NAND.bat
  c flags: Optim=1 wLevel=2
  c define: TEST_SM TEST_CDROM
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
target NAND&SD (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: w55fa95_MSC_NAND_SD_CDROM (library)
  AfterMake: "CDROM_NAND&SD.bat"
  c flags: Optim=1 wLevel=2
  c define: TEST_SM TEST_CDROM TEST_SD
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
target RAM (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: w55fa95_MSC_RAM_CDROM (library)
  AfterMake: CDROM_RAM.bat
  c flags: Optim=1 wLevel=2
  c define: TEST_CDROM TEST_RAM
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
target SPI (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: w55fa95_MSC_SPI_CDROM (library)
  AfterMake: CDROM_SPI.bat
  c flags: Optim=1 wLevel=2
  c define: TEST_CDROM TEST_SPI
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
target All (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: w55fa95_MSC_All_CDROM (library)
  AfterMake: CDROM_All.bat
  c flags: Optim=1 wLevel=2
  c define: TEST_SM TEST_CDROM TEST_SD TEST_RAM
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
target CDROM_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: w55fa95_MSC_CDROM_Only (library)
  AfterMake: CDROM_Only.bat
  c flags: Optim=1 wLevel=2
  c define: TEST_CDROM
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
