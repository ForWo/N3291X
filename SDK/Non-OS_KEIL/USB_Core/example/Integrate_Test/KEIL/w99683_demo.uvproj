# Keil uVision project w99683_demo.uvproj, settings and files
target Release (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: w99683_demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\..\..\lib;..\..\..\..\SYSLIB\Lib;..\..\..\..\NVTFAT\lib;..\..\..\..\GPIO\lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32916\N32916.sct
  link misc: --entry 0
  group Source Group 1
    ../: main.c standalone.c usb_keyboard.c usbbasic.c W99683.c wb_init.s
    ../../../lib/: W55FA95_usbh.lib
    ../../../../SYSLIB/Lib/: W55FA95_syslib.lib
    ../../../../NVTFAT/lib/: W55FA95_nvtfat.lib
    ../../../../GPIO/lib/: w55fa95_gpio.lib
