# Keil uVision project dev_sic.uvproj, settings and files
target DebugRel (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: W55FA95_SIC (library)
  AfterMake: DebugRel.bat
  c flags: Optim=1 wLevel=2
  c include: ..\..\Lib;..\..\..\SYSLIB\Lib;..\..\..\GNAND\Lib;..\..\..\NVTFAT\lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group Source Group 1
    ../: fmi.c NandDrv.c sd.c SDGlue.c sic.c
target Rainbow (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: W55FA95_SIC_KLE (library)
  AfterMake: Rainbow.bat
  c flags: Optim=1 wLevel=2
  c define: __OPT_SW_WP_GPA0 __OPT_NAND_CARD_DETECT_GPD14
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
target KLE_MUL2 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: W55FA95_SIC_KLE_MUL2 (library)
  AfterMake: KLE_MUL2.bat
  c flags: Optim=1 wLevel=2
  c define: __OPT_SW_WP_GPA0 __OPT_NAND2_CARD __OPT_NAND_CARD_DETECT_GPD14
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
target NCWriter (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: W55FA95_SIC_NCW (library)
  AfterMake: NCWriter.bat
  c flags: Optim=1 wLevel=2
  c define: __OPT_NCWriter __OPT_NAND_CARD_DETECT_GPD14
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
