# Keil uVision project NCWriter.uvproj, settings and files
target NCWriter (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: NCWriter
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_WVGA_
  c include: ..\..\..\SIC\Lib;..\..\..\NVTFAT\lib;..\..\..\SYSLIB\Lib;..\..\..\GNAND\Lib;..\..\..\Font\Lib;..\..\..\VPOST\Lib;..\..\..\GPIO\lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32916\N32916.sct
  link misc: --entry 0
  group Source Group 1
    ../: nvtNandDrv.c ProcessIni.c standalone.c Writer.c wb_init.s
    ../../../GNAND/Lib/: w55fa95_GNAND.lib
    ../../../SIC/Lib/: W55FA95_SIC_NCW.lib
    ../../../NVTFAT/lib/: W55FA95_nvtfat.lib
    ../../../SYSLIB/Lib/: W55FA95_syslib.lib
    ../../../GPIO/lib/: w55fa95_gpio.lib
