# Keil uVision project Secureic.uvproj, settings and files
target DebugRel (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: Secureic
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\Lib;..\..\..\..\SYSLIB\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32916\N32916.sct
  link misc: --entry 0
  group Source Group 1
    ../: standalone.c wb_init.s Secureic.c Rootkey.c
    ../../../Lib/: w55fa95_Secureic.lib w55fa95_SPI.lib
    ../../../../SYSLIB/Lib/: W55FA95_syslib.lib
