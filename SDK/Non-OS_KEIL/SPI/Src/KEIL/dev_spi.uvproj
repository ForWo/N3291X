# Keil uVision project dev_spi.uvproj, settings and files
target DebugRel (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: w55fa95_SPI (library)
  AfterMake: DebugRel.bat
  c flags: Optim=1 wLevel=2
  c include: ..\..\Lib;..\..\..\SYSLIB\Lib;..\..\..\NVTFAT\lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group Source Group 1
    ../: spi.c spiflash.c SPIGlue.c
target Debug (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: w55fa95_SPI (library)
  AfterMake: Debug.bat
  c flags: Optim=1 wLevel=2
  c include: ..\..\Lib;..\..\..\SYSLIB\Lib;..\..\..\NVTFAT\lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
target Release (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: w55fa95_SPI (library)
  AfterMake: Release.bat
  c flags: Optim=1 wLevel=2
  c include: ..\..\Lib;..\..\..\SYSLIB\Lib;..\..\..\NVTFAT\lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
