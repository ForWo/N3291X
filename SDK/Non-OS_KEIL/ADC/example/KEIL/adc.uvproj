# Keil uVision project adc.uvproj, settings and files
target AudioRecord (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: adc
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\Lib;..\..\..\SYSLIB\Lib;..\..\..\SIC\Lib;..\..\..\GNAND\Lib;..\..\..\NVTFAT\lib;..\..\..\VPOST\Lib;..\..\..\EDMA\lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32916\N32916.sct
  link misc: --entry 0
  group Source Group 1
    ../: adc.c audioRecord.c standalone.c TouchPanel.c wb_init.s
    ../../Lib/: W55FA95_adc.lib
    ../../../EDMA/lib/: w55fa95_edma.lib
    ../../../SIC/Lib/: W55FA95_SIC.lib
    ../../../NVTFAT/lib/: W55FA95_nvtfat.lib
    ../../../SYSLIB/Lib/: W55FA95_syslib.lib
    ../../../VPOST/Lib/: W55FA95_VPOST.lib
target block (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: adc
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32916\N32916.sct
  link misc: --entry 0
target nonblock (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: adc
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _ADC_NONBLOCK_
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32916\N32916.sct
  link misc: --entry 0
target Touch_WakeUp (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: adc
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32916\N32916.sct
  link misc: --entry 0
