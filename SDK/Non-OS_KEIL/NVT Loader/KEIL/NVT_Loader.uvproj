# Keil uVision project NVT_Loader.uvproj, settings and files
target NAND_AMPIRE_WVGA_18_IN (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: NVT_NAND_AMPIRE_WVGA_18B_IN
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCM_800x480__ __NVT_MP_WVGA_IN_DEMO__ __ENABLE_NAND_0__
  c include: ..\..\ADC\Lib;..\..\AVI\Lib;..\..\GPIO\lib;..\..\KPI\lib;..\..\UDC\lib;..\..\VPOST\Lib;..\..\GNAND\Lib;..\..\I2C\lib;..\..\JPEG\LIB;..\..\NVTFAT\lib;..\..\RTC\LIB;..\..\SIC\Lib;..\..\GNAND\Lib;..\..\SPU\Lib;..\..\SYSLIB\Lib;..\inc
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\src\scat.scf
  link misc: --entry Reset_Go
  group Source Group 1
    ../src/: heap.s AdapterCtl.c avi.c LcmCtl.c main.c mass.c nand_post_process.c NVT_I2C.c NVT_mp3.c NVT_BatteryDect.c NVT_Update.c stack.s standalone.c vectors.s wb_init.s SpeakerCtl.c
    ../../AVI/Lib/: AviLib_800x480.lib ima_adpcm_codec.lib mp3lib.lib
    ../../GPIO/lib/: w55fa95_gpio.lib
    ../../KPI/lib/: w55fa95_kpi_11x1_lcd.lib w55fa95_kpi_1x3_gpio.lib w55fa95_kpi_1x4_gpio.lib w55fa95_kpi_1x4_gpio_g.lib w55fa95_kpi_1x6_gpio.lib
    ../../UDC/lib/: w55fa95_MSC_NAND.lib w55fa95_MSC_SD.lib w55fa95_UDC.lib w55fa95_UDC_Fullspeed.lib
    ../../VPOST/Lib/: W55FA95_VPOST_AMPIRE_800x480_18B.lib
    ../../ADC/Lib/: W55FA95_adc.lib
    ../../GNAND/Lib/: w55fa95_GNAND.lib
    ../../I2C/lib/: w55fa95_i2c.lib
    ../../JPEG/LIB/: w55fa95_jpeglib.lib
    ../../NVTFAT/lib/: W55FA95_nvtfat.lib
    ../../RTC/LIB/: w55fa95_RTClib.lib
    ../../SIC/Lib/: W55FA95_SIC.lib W55FA95_SIC_KLE.lib W55FA95_SIC_KLE_MUL2.lib
    ../../SPU/Lib/: w55fa95_spu.lib w55fa95_spu_KLE.lib
    ../../SYSLIB/Lib/: W55FA95_syslib.lib
target SD_AMPIRE_WVGA_18_IN (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: NVT_SD0_AMPIRE_WVGA_18B_IN
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCM_800x480__ __ICE__ __NVT_MP_WVGA_IN_DEMO__ __ENABLE_SD_CARD_0__
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\src\scat.scf
  link misc: --entry Reset_Go
