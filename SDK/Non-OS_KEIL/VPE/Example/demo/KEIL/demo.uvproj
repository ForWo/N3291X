# Keil uVision project demo.uvproj, settings and files
target VPE_MMU_GW_480x272 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: LCM_480X272
  c include: ..\..\..\Lib;..\..\..\..\SYSLIB\Lib;..\..\..\..\GNAND\Lib;..\..\..\..\NVTFAT\lib;..\..\..\..\SIC\Lib;..\..\demo;..\..\..\..\VPOST\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\N32916\N32916.sct
  link misc: --entry 0
  group Source Group 1
    ../../: standalone.c VPE_Aspect.c VPE_Emulation.c VPE_FileAccess.c VPE_FormatConversionRotation_TV.c wb_init.s
    ../../../Lib/: W55FA95_VPE.lib
    ../../../../NVTFAT/lib/: W55FA95_nvtfat.lib
    ../../../../SIC/Lib/: W55FA95_SIC.lib
    ../../../../SYSLIB/Lib/: W55FA95_syslib.lib
    ../../../../VPOST/Lib/: W55FA95_VPOST.lib
