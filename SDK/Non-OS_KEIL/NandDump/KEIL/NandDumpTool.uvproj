# Keil uVision project NandDumpTool.uvproj, settings and files
target DebugRel (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: NandDumpTool
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\SIC\Lib;..\..\GNAND\Lib;..\..\SYSLIB\Lib;..\..\NVTFAT\lib;..\..\SIC\Src
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\N32916\N32916.sct
  link misc: --entry 0
  group Source Group 1
    ../: main.c standalone.c wb_init.s
    ../../NVTFAT/lib/: W55FA95_nvtfat.lib
    ../../SYSLIB/Lib/: W55FA95_syslib.lib
    ../../SIC/Lib/: W55FA95_SIC.lib
