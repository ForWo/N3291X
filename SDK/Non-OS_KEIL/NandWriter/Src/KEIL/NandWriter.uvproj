# Keil uVision project NandWriter.uvproj, settings and files
target 480x272 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: NandWriter
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_WVGA_
  c include: ..\..\..\SIC\Lib;..\..\..\NVTFAT\lib;..\..\..\SYSLIB\Lib;..\..\..\GNAND\Lib;..\..\..\Font\Lib;..\..\..\VPOST\Lib;..\..\..\GPIO\lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32916\N32916.sct
  link misc: --entry 0
  group Source Group 1
    ../: DrawFont.c LcmCtl.c nvtNandDrv.c ProcessIni.c ProcessOptionalIni.c standalone.c Writer.c wb_init.s
    ../../../GNAND/Lib/: w55fa95_GNAND.lib
    ../../../SIC/Lib/: W55FA95_SIC.lib W55FA95_SIC_KLE.lib W55FA95_SIC_KLE_MUL2.lib
    ../../../NVTFAT/lib/: W55FA95_nvtfat.lib
    ../../../SYSLIB/Lib/: W55FA95_syslib.lib
    ../../../VPOST/Lib/: W55FA95_VPOST.lib
    ../../../GPIO/lib/: w55fa95_gpio.lib
    ../../../Font/Lib/: Font_QVGA.lib Font_SVGA.lib Font_WSVGA.lib
target QVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: NandWriter
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_QVGA_
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32916\N32916.sct
  link misc: --entry 0
target WSVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: NandWriter
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_WSVGA_
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32916\N32916.sct
  link misc: --entry 0
