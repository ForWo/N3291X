# Keil uVision project SpiWriter.uvproj, settings and files
target N32915_WSVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: SpiWriter(S)_WSVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_WSVGA_ __Security__
  c include: ..\..\..\SIC\Lib;..\..\..\NVTFAT\lib;..\..\..\SYSLIB\Lib;..\..\..\GNAND\Lib;..\..\..\Font\Lib;..\..\..\VPOST\Lib;..\..\..\GPIO\lib;..\..\..\SPU\Lib;..\..\..\SPI\lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32916\N32916.sct
  link misc: --entry 0
  group Source Group 1
    ../: DrawFont.c playsound.c ProcessIni.c ProcessOptionalIni.c spiflash.c standalone.c Writer.c wb_init.s Rootkey.c
    ../../../SIC/Lib/: W55FA95_SIC.lib
    ../../../NVTFAT/lib/: W55FA95_nvtfat.lib
    ../../../GPIO/lib/: w55fa95_gpio.lib
    ../../../SPU/Lib/: w55fa95_spu.lib
    ../../../VPOST/Lib/: W55FA95_VPOST.lib
    ../../../SYSLIB/Lib/: W55FA95_syslib.lib
    ../../../Font/Lib/: Font_QVGA.lib Font_SVGA.lib Font_WSVGA.lib
    ../../../SPI/Lib/: w55fa95_Secureic.lib
target N32915_NoLCM (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SpiWriter(S)
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __Security__ __NoLCM__
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32916\N32916.sct
  link misc: --entry 0
