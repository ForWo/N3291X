# Keil uVision project SysLib.uvproj, settings and files
target Syslib (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: W55FA95_syslib (library)
  AfterMake: Syslib.bat
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group Source Group 1
    ../../: wb_aic.c wb_cache.c wb_config.c wb_dcache.s wb_mmu.c wb_power.c wb_sysctl.s wb_timer.c wb_uart.c
