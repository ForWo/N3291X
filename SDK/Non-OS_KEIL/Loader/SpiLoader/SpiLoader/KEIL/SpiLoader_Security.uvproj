# Keil uVision project SpiLoader_Security.uvproj, settings and files
target AMPIRE_WVGA_18 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: SpiLoader(S)_AMPIRE_WVGA_18B
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __LCM_800x480__ __Security__
  c include: ..\inc;..\..\..\..\SYSLIB\Lib;..\..\..\..\VPOST\Lib;..\..\..\..\SPU\Lib;..\..\..\..\SPI\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\src\scat.scf
  link misc: --entry Reset_Go
  group Source Group 1
    ../src/: main.c SpiRead.c standalone.c heap.s stack.s vectors.s wb_init.s Rootkey.c
    ../../../../VPOST/Lib/: W55FA95_VPOST.lib
    ../../../../SPU/Lib/: w55fa95_spu.lib
    ../../../../SYSLIB/Lib/: W55FA95_syslib.lib
    ../../../../SPI/Lib/: w55fa95_Secureic.lib
target NoLCM (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SpiLoader(S)
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __No_LCM__ __Security__
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\src\scat.scf
  link misc: --entry Reset_Go
