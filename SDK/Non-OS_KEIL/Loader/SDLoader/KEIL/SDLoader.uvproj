# Keil uVision project SDLoader.uvproj, settings and files
target SDLoader_not_set_clock (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: SDLoader_not_set_clock
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: __UPLL_NOT_SET__
  c include: ..\..\..\VPOST\Lib;..\..\..\SYSLIB\Lib;..\..\..\SPU\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\SdLoader.scf
  link misc: --entry Reset_Go
  group Source Group 1
    ../: Depop.c heap.s sd.c SdLoader.c stack.s standalone.c vectors.s wb_aic.c wb_cache.c wb_config.c wb_dcache.s wb_init.s wb_mmu.c wb_sysctl.s wb_timer.c wb_uart.c
target SDLoader_300MHz (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SDLoader_300MHz
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: __UPLL_300__
  c include: ..\..\..\VPOST\Lib;..\..\..\SYSLIB\Lib;..\..\..\SPU\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\SdLoader.scf
  link misc: --entry Reset_Go
target SDLoader_264MHz (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SDLoader_264MHz
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: __UPLL_264__
  c include: ..\..\..\VPOST\Lib;..\..\..\SYSLIB\Lib;..\..\..\SPU\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\SdLoader.scf
  link misc: --entry Reset_Go
target SDLoader_288MHz (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: SDLoader_288MHz
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: __UPLL_288__
  c include: ..\..\..\VPOST\Lib;..\..\..\SYSLIB\Lib;..\..\..\SPU\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\SdLoader.scf
  link misc: --entry Reset_Go
