# Keil uVision project NandLoader.uvproj, settings and files
target NANDLoader_not_set_clock (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: NANDLoader_not_set_clock
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: __UPLL_NOT_SET__
  c include: ..\..\..\SYSLIB\Lib;..\..\..\VPOST\Lib;..\..\..\SPU\Lib;..\..\..\ADC\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\NandLoader.scf
  link misc: --entry Reset_Go
  group Source Group 1
    ../: Depop.c heap.s NandDrv.c NandLoader.c NVT_BatteryDect.c stack.s standalone.c vectors.s wb_aic.c wb_cache.c wb_config.c wb_dcache.s wb_init.s wb_mmu.c wb_sysctl.s wb_timer.c wb_uart.c
    ../../../ADC/Lib/: W55FA95_adc.lib
    ../../../UDC/lib/: w55fa95_UDC.lib
    ../../../RTC/LIB/: w55fa95_RTClib.lib
target NANDLoader_300MHz (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: NANDLoader_300MHz
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: __UPLL_300__
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\NandLoader.scf
  link misc: --entry Reset_Go
target NANDLoader_300MHz_no_RTC (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: NANDLoader_300MHz_no_RTC
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: __UPLL_300__ __DISABLE_RTC__
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\NandLoader.scf
  link misc: --entry Reset_Go
target NANDLoader_288MHz (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: NANDLoader_288MHz
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: __UPLL_288__
  c include: as above
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\NandLoader.scf
  link misc: --entry Reset_Go
