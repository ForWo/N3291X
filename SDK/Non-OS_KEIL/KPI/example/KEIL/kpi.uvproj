# Keil uVision project kpi.uvproj, settings and files
target nonblock (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: kpi
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _KPI_NONBLOCK_
  c include: ..\..\lib;..\..\..\SYSLIB\Lib;..\..\..\VPOST\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32916\N32916.sct
  link misc: --entry 0
  group Source Group 1
    ../: kpi.c standalone.c wb_init.s
    ../../lib/: w55fa95_kpi_11x1_lcd.lib
    ../../../SYSLIB/Lib/: W55FA95_syslib.lib
    ../../../VPOST/Lib/: W55FA95_VPOST.lib
target block (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: kpi
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\lib;..\..\..\SYSLIB\Lib;..\..\..\VPOST\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32916\N32916.sct
  link misc: --entry 0
