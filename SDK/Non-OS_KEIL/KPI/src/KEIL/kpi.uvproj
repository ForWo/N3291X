# Keil uVision project kpi.uvproj, settings and files
target kpi_8x1_lcd (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: w55fa95_kpi_8x1_lcd (library)
  AfterMake: kpi_8x1_lcd.bat
  c flags: Optim=1 wLevel=2
  c include: ..\..\Lib;..\..\..\SYSLIB\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group Source Group 1
    ../: DrvKPI.c libkpi_1x3_gpio.c libkpi_1x4_gpio.c libkpi_1x4_gpio_g.c libkpi_1x6_gpio.c libkpi_8x1_lcd.c libkpi_11x1_lcd.c libkpi_16x4_lcd.c
    ../../../GPIO/lib/: w55fa95_gpio.lib
target kpi_16x4_lcd (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: w55fa95_kpi_16x4_lcd (library)
  AfterMake: kpi_16x4_lcd.bat
  c flags: Optim=1 wLevel=2
  c include: ..\..\Lib;..\..\..\SYSLIB\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
target kpi_1x4_gpio (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: w55fa95_kpi_1x4_gpio (library)
  AfterMake: kpi_1x4_gpio.bat
  c flags: Optim=1 wLevel=2
  c include: ..\..\Lib;..\..\..\SYSLIB\Lib;..\..\..\GPIO\lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
target kpi_11x1_lcd (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: w55fa95_kpi_11x1_lcd (library)
  AfterMake: kpi_11x1_lcd.bat
  c flags: Optim=1 wLevel=2
  c include: ..\..\Lib;..\..\..\SYSLIB\Lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
target kpi_1x6_gpio (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: w55fa95_kpi_1x6_gpio (library)
  AfterMake: kpi_1x6_gpio.bat
  c flags: Optim=1 wLevel=2
  c include: ..\..\Lib;..\..\..\SYSLIB\Lib;..\..\..\GPIO\lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
target kpi_1x3_gpio (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: w55fa95_kpi_1x3_gpio (library)
  AfterMake: kpi_1x3_gpio.bat
  c flags: Optim=1 wLevel=2
  c include: ..\..\Lib;..\..\..\SYSLIB\Lib;..\..\..\GPIO\lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
target kpi_1x4_gpio_g (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: w55fa95_kpi_1x4_gpio_g (library)
  AfterMake: kpi_1x4_gpio_g.bat
  c flags: Optim=1 wLevel=2
  c include: ..\..\Lib;..\..\..\SYSLIB\Lib;..\..\..\GPIO\lib
  memory RVCT9: RAM 0xf8002000 size 0x8000
