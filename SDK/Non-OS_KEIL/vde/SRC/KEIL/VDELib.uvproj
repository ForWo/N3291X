# Keil uVision project VDELib.uvproj, settings and files
target FA95_VDE_REL (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: w55fa95_vde (library)
  AfterMake: FA95_VDE_REL.bat
  c flags: Optim=1 wLevel=2
  c include: ..\..\LIB;..\..\..\SYSLIB\Lib;..\Wrapper;..\CnMSrc
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group Source Group 1
    ../Wrapper/: VdoAPI.c
    ../CnMSrc/: VpuApi.c VpuApiFunc.c
target FA95_VDE_DBG (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: w55fa95_vde (library)
  AfterMake: FA95_VDE_DBG.bat
  c flags: Optim=1 wLevel=2
  c include: ..\..\LIB;..\..\..\SYSLIB\Lib;..\Wrapper;..\CnMSrc
  memory RVCT9: RAM 0xf8002000 size 0x8000
