# Keil uVision project demo.uvproj, settings and files
target OUTPUT_TO_LCM (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: demo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _No_VPE_Upscale_ _OUTPUT_TO_LCM_
  c include: ..\..\LIB;..\..\..\SYSLIB\Lib;..\..\..\SIC\Lib;..\..\..\VPE\Lib;..\..\..\VPOST\Lib;..\..\..\NVTFAT\lib;..\SRC;..\..\..\GNAND\Lib;..\..\SRC\CnMSrc
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\N32916\N32916.sct
  link misc: --entry 0
  group Source Group 1
    ../SRC/: APITest.c APITestSubF.c basicfun.c H264Pattern.c InitVpe.c interrupt.c main.c
    ../wb_init/: standalone.c wb_init.s
    ../../LIB/: w55fa95_vde.lib
    ../../../SYSLIB/Lib/: W55FA95_syslib.lib
    ../../../SIC/Lib/: W55FA95_SIC.lib
    ../../../VPE/Lib/: W55FA95_VPE.lib
    ../../../VPOST/Lib/: W55FA95_VPOST.lib
    ../../../NVTFAT/lib/: W55FA95_nvtfat.lib
